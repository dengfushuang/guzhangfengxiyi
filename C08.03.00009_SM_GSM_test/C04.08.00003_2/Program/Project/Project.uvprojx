# Keil uVision project Project.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\Core;..\Libraries\Device\include;..\Startup;..\User;..\ucOSII2.91\Config;..\ucOSII2.91\Ports;..\ucOSII2.91\Source;..\ucOSII2.91\Cpu;..\Hardware\uart;..\Hardware\led;..\Hardware\74hc595;..\Hardware\lcd16032;..\Hardware\delay;..\uip\lib;..\uip\arch\STM32;..\uip\src;..\uip\app;..\uip\app\http;..\Hardware\DP83848;..\Hardware\ADC;..\Hardware\OSW;..\Hardware\RTC;..\Hardware\AT24C512;..\Hardware\eeprom;..\Hardware\DS18B20;..\Hardware\I2C;..\Drivers\source;..\Hardware\sim800c;..\Hardware\my_inet
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c OS_AppHooks.c User_TimeTicks.c cmd_process.c log.c cJSON.c
  group Hardware
    ../Hardware/delay/: delay.c
    ../Hardware/uart/: queue.c uart0.c uart.c
    ../Hardware/ADC/: ADC.c
    ../Hardware/eeprom/: lpc177x_8x_eeprom.c
    ../Hardware/sim800c/: sim800c.c
    ../Hardware/my_inet/: my_inet.c
  group Startup
    ../Startup/: startup_LPC17xx.s
  group Libraries/core
    ../Libraries/Core/: core_cm3.c LPC177x_8x.h system_LPC177x_8x.c
  group ucOS/Ports
    ../ucOSII2.91/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucOS/Source
    ../ucOSII2.91/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucOS/Config
    ../ucOSII2.91/Config/: os_cfg.h
software components: CMSIS:CORE 4.3.0
